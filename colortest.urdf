Commit message: minor layout changes

File: colortest.urdf (robot description, URDF)
Before this commit: robot colortest, 2 links, 0 joints
Links:
- removed link base_link
- removed link box_one
- added link box_one ; visual box size=1 1 1
- added link sphere_one; visual sphere radius=0.5
