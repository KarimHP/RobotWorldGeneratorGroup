Commit message: r2d2 revolute joints

File: r2d2generated.urdf (robot description, URDF)
Before this commit: robot r2d2generated, 3 links, 2 joints
Joints:
- joint base_to_left_leg: axis (none) -> 1 0 0; limit (none) -> lower=0 upper=0 effort=1 velocity=1; type fixed -> revolute
